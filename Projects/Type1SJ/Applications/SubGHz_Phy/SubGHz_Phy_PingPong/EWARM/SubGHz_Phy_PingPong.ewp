# IAR project SubGHz_Phy_PingPong.ewp, settings and files
configuration lbaa0qb1sj (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072CZ ST STM32L072CZ
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: STM32L072xx; USE_MURATA_SX126X
  ICCARM.CCIncludePath2: ../SubGHz_Phy/App; ../SubGHz_Phy/Target; ../Core/Inc; ../../../../../../Utilities/misc; ../../../../../../Utilities/timer; ../../../../../../Utilities/trace/adv_trace; ../../../../../../Utilities/lpm/tiny_lpm; ../../../../../../Utilities/sequencer; ../../../../../../Drivers/BSP/B-L072Z-LRWAN1; ..\..\..\..\..\..\Drivers\BSP\MurataSx126xModule; ../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc; ../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Middlewares/Third_Party/SubGHz_Phy; ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx1276
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SubGHz_Phy_PingPong.bin
  ILINK.IlinkOutputFile: lbaa0qb1sj.out
  ILINK.IlinkIcfFile: stm32l072xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/App
    ../SubGHz_Phy/App/: app_subghz_phy.c subghz_phy_app.c
  group Application/Core
    ../Core/Src/: dma.c main.c rtc.c rtc_if.c stm32_lpm_if.c stm32l0xx_hal_msp.c stm32l0xx_it.c sys_app.c sys_debug.c usart.c usart_if.c
  group Application/EWARM
    ./: startup_stm32l072xx.s
  group Application/Target
    ../SubGHz_Phy/Target/: b_l072z_lrwan1_bus.c
  group Doc
    ../: readme.txt
  group Drivers/BSP/B-L072Z-LRWAN1
    ../../../../../../Drivers/BSP/B-L072Z-LRWAN1/: b-l072z-lrwan1.c
  group Drivers/BSP/MurataSx126xModule
    ../../../../../../Drivers/BSP/MurataSx126xModule/: muratasx126xmodule.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../../../../../../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group Middlewares/SubGHz_Phy
    ../../../../../../Middlewares/Third_Party/SubGHz_Phy/sx126x/: radio.c sx126x.c
  group Utilities
    ../../../../../../Utilities/trace/adv_trace/: stm32_adv_trace.c
    ../../../../../../Utilities/lpm/tiny_lpm/: stm32_lpm.c
    ../../../../../../Utilities/misc/: stm32_mem.c stm32_systime.c stm32_tiny_vsnprintf.c
    ../../../../../../Utilities/sequencer/: stm32_seq.c
    ../../../../../../Utilities/timer/: stm32_timer.c
